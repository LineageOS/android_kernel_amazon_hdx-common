## arch/arm/configs/apollo_defconfig
```kconfig
CONFIG_ARCH_MSM8974_APOLLO=y
CONFIG_SND_SOC_MSM8974_APOLLO=y
CONFIG_LEDS_QPNP=y
CONFIG_LEDS_TRIGGER_BACKLIGHT=y
CONFIG_LEDS_TRIGGER_DEFAULT_ON=y
```
